.include ./FreePDK45/ncsu_basekit/models/hspice/hspice_nom.include
.include ./FreePDK45/osu_soc/lib/source/netlists/AND2X1.pex.netlist
.include ./FreePDK45/osu_soc/lib/source/netlists/NAND2X1.pex.netlist
.include ./FreePDK45/osu_soc/lib/source/netlists/OR2X1.pex.netlist
.include ./FreePDK45/osu_soc/lib/source/netlists/NOR2X1.pex.netlist
.include ./FreePDK45/osu_soc/lib/source/netlists/BUFX2.pex.netlist
.include ./FreePDK45/osu_soc/lib/source/netlists/INVX1.pex.netlist
.include ./FreePDK45/osu_soc/lib/source/netlists/XOR2X1.pex.netlist
.include ./FreePDK45/osu_soc/lib/source/netlists/XNOR2X1.pex.netlist
.option TEMP=27c
Vpower Vdd 0 1.1
Vgnd Vss 0 0
Vin0 V0 0 dc pulse (0 1.1 6n 1n 1n 28n 54n)
Vin1 V1 0 dc pulse (0 1.1 5n 1n 1n 29n 48n)
Cload101 V101 0 0.00155103pF
XOR2 V1 V2 V1 Vdd Vss XOR2X1
XOR3 V1 V3 V0 Vdd Vss XOR2X1
XAND4 V3 V1 Vdd Vss V4 AND2X1
XOR5 V1 V3 Vdd Vss V5 OR2X1
XOR6 V4 V6 V0 Vdd Vss XOR2X1
XNOR7 V4 Vdd V4 V7 Vss NOR2X1
XOR8 V2 V8 V3 Vdd Vss XOR2X1
XNAND9 V4 Vss V5 V9 Vdd NAND2X1
XAND10 V0 V3 Vdd Vss V10 AND2X1
XOR11 V1 V11 V2 Vdd Vss XOR2X1
XOR12 V5 V12 V11 Vdd Vss XOR2X1
XBUF13 V13 Vss Vdd V8 BUFX2
XBUF14 V14 Vss Vdd V3 BUFX2
XNOR15 V14 V15 V14 Vss Vdd XNOR2X1
XNOR16 V0 V16 V5 Vss Vdd XNOR2X1
XINV17 V2 Vss Vdd V17 INVX1
XOR18 V10 V9 Vdd Vss V18 OR2X1
XBUF19 V19 Vss Vdd V1 BUFX2
XOR20 V0 V20 V17 Vdd Vss XOR2X1
XNAND21 V9 Vss V13 V21 Vdd NAND2X1
XAND22 V18 V20 Vdd Vss V22 AND2X1
XNAND23 V13 Vss V2 V23 Vdd NAND2X1
XAND24 V17 V8 Vdd Vss V24 AND2X1
XNAND25 V11 Vss V6 V25 Vdd NAND2X1
XINV26 V3 Vss Vdd V26 INVX1
XNOR27 V16 V27 V1 Vss Vdd XNOR2X1
XNOR28 V8 V28 V2 Vss Vdd XNOR2X1
XNOR29 V9 Vdd V26 V29 Vss NOR2X1
XOR30 V8 V30 V18 Vdd Vss XOR2X1
XNAND31 V8 Vss V22 V31 Vdd NAND2X1
XNAND32 V8 Vss V18 V32 Vdd NAND2X1
XOR33 V7 V9 Vdd Vss V33 OR2X1
XBUF34 V34 Vss Vdd V8 BUFX2
XNOR35 V33 V35 V8 Vss Vdd XNOR2X1
XBUF36 V36 Vss Vdd V28 BUFX2
XBUF37 V37 Vss Vdd V29 BUFX2
XNOR38 V6 V38 V6 Vss Vdd XNOR2X1
XNAND39 V24 Vss V18 V39 Vdd NAND2X1
XNOR40 V23 V40 V35 Vss Vdd XNOR2X1
XINV41 V0 Vss Vdd V41 INVX1
XNAND42 V26 Vss V23 V42 Vdd NAND2X1
XNOR43 V24 V43 V9 Vss Vdd XNOR2X1
XINV44 V18 Vss Vdd V44 INVX1
XAND45 V9 V1 Vdd Vss V45 AND2X1
XINV46 V13 Vss Vdd V46 INVX1
XNAND47 V10 Vss V45 V47 Vdd NAND2X1
XOR48 V34 V29 Vdd Vss V48 OR2X1
XNOR49 V17 V49 V34 Vss Vdd XNOR2X1
XNOR50 V48 Vdd V8 V50 Vss NOR2X1
XNOR51 V35 V51 V7 Vss Vdd XNOR2X1
XNOR52 V32 Vdd V48 V52 Vss NOR2X1
XOR53 V30 V53 V52 Vdd Vss XOR2X1
XNAND54 V53 Vss V3 V54 Vdd NAND2X1
XOR55 V19 V55 V10 Vdd Vss XOR2X1
XINV56 V42 Vss Vdd V56 INVX1
XOR57 V24 V31 Vdd Vss V57 OR2X1
XOR58 V15 V58 V42 Vdd Vss XOR2X1
XINV59 V33 Vss Vdd V59 INVX1
XNOR60 V46 Vdd V59 V60 Vss NOR2X1
XNOR61 V11 Vdd V15 V61 Vss NOR2X1
XAND62 V37 V44 Vdd Vss V62 AND2X1
XOR63 V17 V63 V53 Vdd Vss XOR2X1
XAND64 V38 V27 Vdd Vss V64 AND2X1
XINV65 V50 Vss Vdd V65 INVX1
XBUF66 V66 Vss Vdd V42 BUFX2
XAND67 V31 V22 Vdd Vss V67 AND2X1
XOR68 V36 V58 Vdd Vss V68 OR2X1
XNAND69 V1 Vss V19 V69 Vdd NAND2X1
XAND70 V50 V58 Vdd Vss V70 AND2X1
XOR71 V64 V36 Vdd Vss V71 OR2X1
XNOR72 V48 Vdd V20 V72 Vss NOR2X1
XAND73 V36 V17 Vdd Vss V73 AND2X1
XNOR74 V25 V74 V10 Vss Vdd XNOR2X1
XBUF75 V75 Vss Vdd V47 BUFX2
XOR76 V36 V76 V39 Vdd Vss XOR2X1
XOR77 V16 V77 V17 Vdd Vss XOR2X1
XBUF78 V78 Vss Vdd V15 BUFX2
XNAND79 V14 Vss V48 V79 Vdd NAND2X1
XNOR80 V40 Vdd V15 V80 Vss NOR2X1
XAND81 V54 V59 Vdd Vss V81 AND2X1
XBUF82 V82 Vss Vdd V33 BUFX2
XBUF83 V83 Vss Vdd V23 BUFX2
XNAND84 V61 Vss V15 V84 Vdd NAND2X1
XNOR85 V22 V85 V83 Vss Vdd XNOR2X1
XBUF86 V86 Vss Vdd V33 BUFX2
XNOR87 V79 V87 V22 Vss Vdd XNOR2X1
XINV88 V23 Vss Vdd V88 INVX1
XAND89 V78 V43 Vdd Vss V89 AND2X1
XNOR90 V89 V90 V50 Vss Vdd XNOR2X1
XBUF91 V91 Vss Vdd V39 BUFX2
XAND92 V67 V77 Vdd Vss V92 AND2X1
XNOR93 V70 Vdd V81 V93 Vss NOR2X1
XBUF94 V94 Vss Vdd V73 BUFX2
XOR95 V86 V95 V17 Vdd Vss XOR2X1
XNOR96 V71 Vdd V55 V96 Vss NOR2X1
XOR97 V49 V65 Vdd Vss V97 OR2X1
XBUF98 V98 Vss Vdd V78 BUFX2
XNOR99 V0 V99 V93 Vss Vdd XNOR2X1
XAND100 V47 V12 Vdd Vss V100 AND2X1
XOR101 V92 V101 V14 Vdd Vss XOR2X1
.tran 0.1n 100n 0 1p
.probe P(Vpower)
.control
run
plot -Vpower:power
meas tran power_avg avg Vpower:power
wrdata power_consumption.txt Vpower:power
.endc
* Leakage power estimation: 1891.47662 nW
